# IAR project Project.ewp, settings and files
configuration STM32N657xx (ARM, debug)
  General.OGChipSelectEditMenu: STM32N6570-DK ST STM32N6570-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; VECT_TAB_SRAM
  ICCARM.CCIncludePath2: ..\Inc; ..\STM32Cube_FW_N6\Drivers\STM32N6xx_HAL_Driver\Inc; ..\STM32Cube_FW_N6\Drivers\STM32N6xx_HAL_Driver\Inc\Legacy; ..\STM32Cube_FW_N6\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\STM32Cube_FW_N6\Drivers\CMSIS\Include; ..\STM32Cube_FW_N6\Drivers\CMSIS\DSP\Include; ..\STM32Cube_FW_N6\Drivers\BSP\Components\Common; ..\STM32Cube_FW_N6\Drivers\BSP\STM32N6570-DK; ..\STM32Cube_FW_N6\Utilities\lcd; ..\STM32Cube_FW_N6\Drivers\BSP\Components\aps256xx; ..\Middlewares\Camera_Middleware\sensors; ..\Middlewares\Camera_Middleware\sensors\imx335; ..\Middlewares\Camera_Middleware\sensors\vd55g1; ..\Middlewares\Camera_Middleware\sensors\vd6g; ..\Middlewares\Camera_Middleware; ..\Middlewares\ISP_Library\isp\Inc; ..\Middlewares\ISP_Library\evision\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../Src/: hdmi.c main.c stm32_lcd_ex.c stm32n6xx_it.c
  group Drivers/BSP/Components
    ../STM32Cube_FW_N6/Drivers/BSP/Components/aps256xx/: aps256xx.c
  group Drivers/BSP/STM32N6570-DK
    ../STM32Cube_FW_N6/Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c stm32n6570_discovery_bus.c stm32n6570_discovery_lcd.c stm32n6570_discovery_xspi.c
  group Drivers/CMSIS
    ../STM32Cube_FW_N6/Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/iar/: startup_stm32n657xx_fsbl.s
    ../STM32Cube_FW_N6/Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../STM32Cube_FW_N6/Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dcmipp.c stm32n6xx_hal_dma2d.c stm32n6xx_hal_gpio.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_ltdc.c stm32n6xx_hal_ltdc_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_xspi.c
  group Middlewares/Camera_Middleware
    ../Middlewares/Camera_Middleware/: cmw_camera.c cmw_utils.c
  group Middlewares/Camera_Middleware/sensors
    ../Middlewares/Camera_Middleware/sensors/: cmw_imx335.c cmw_vd55g1.c cmw_vd66gy.c
  group Middlewares/Camera_Middleware/sensors/Drivers
    ../Middlewares/Camera_Middleware/sensors/imx335/: imx335.c imx335_reg.c
    ../Middlewares/Camera_Middleware/sensors/vd55g1/: vd55g1.c
    ../Middlewares/Camera_Middleware/sensors/vd6g/: vd6g.c
  group Middlewares/ISP_Library
    ../Middlewares/ISP_Library/isp/Src/: isp_algo.c isp_cmd_parser.c isp_core.c isp_services.c isp_tool_com.c
    ../Middlewares/ISP_Library/evision/Lib/: libn6-evision-awb_iar.a libn6-evision-st-ae_iar.a
  group Utilities/lcd
    ../STM32Cube_FW_N6/Utilities/lcd/: stm32_lcd.c
